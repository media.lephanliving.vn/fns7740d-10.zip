Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-03-28T08:04:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 28 08:04:31 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\56900cc9-f475-441c-a24f-afbbdc529a15\90792ebd-8ad9-42f0-9028-34814d124748\ifc * Database version: 5507 * Database creation date: Thu Mar 28 08:04:27 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 28 08:04:28 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 28 08:04:28 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12361980_EU1_FNS7740D:37774040_EU1_12361980_FNS7740D, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 37774040_EU1_12361980_FNS7740D
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 37774040_EU1_12361980_FNS7740D
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1770 mm; Depth: 544 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_353594
Description: Flow; FlowDirection: SOURCEANDSINK
